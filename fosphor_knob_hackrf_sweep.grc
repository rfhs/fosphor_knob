options:
  parameters:
    generate_options: qt_gui
    id: fosphor_knob_hackrf_sweep
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 3625e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7250e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/shm/hackrf_sweep
    repeat: 'False'
    type: complex
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8080'
  states: {}

connections:
- [blocks_file_source_0, '0', fosphor_glfw_sink_c_0, '0']

metadata:
  file_format: 1
