options:
  parameters:
    generate_options: qt_gui
    id: fosphor_knob_bladerf2_wide
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 122.88e6
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    label: Current Gain
    type: raw
    value: gain
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,sample_format=8,feature=oversample"'
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8080'
  states: {}

connections:
- [osmosdr_source_0, '0', fosphor_glfw_sink_c_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
