options:
  parameters:
    generate_options: qt_gui
    id: fosphor_knob_bladerf2_sponsors
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2462e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 61e6
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    label: Current Gain
    type: raw
    value: gain
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.07'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: items
    maximum: '0.01'
    samples_per_second: samp_rate/100
    type: complex
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0,sample_format=8,feature=oversample
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '0'
    image_file: /usr/share/fosphor_knob/scrolly.png
    image_flip: '1'
    image_invert: '1'
    repeatmode: '1'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '1'
    width: '1080'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8080'
  states: {}

connections:
- [blocks_add_xx_0, '0', fosphor_glfw_sink_c_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_0, '0', blocks_multiply_const_xx_0, '0']
- [osmosdr_source_0, '0', blocks_add_xx_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
