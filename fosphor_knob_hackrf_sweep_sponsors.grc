options:
  parameters:
    generate_options: qt_gui
    id: fosphor_knob_hackrf_sweep_sponsors
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 3625e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7250e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /dev/shm/hackrf_sweep
    repeat: 'True'
    type: complex
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '1'
    bt709_map: '0'
    image_file: /usr/share/fosphor_knob/scrolly.png
    image_flip: '1'
    image_invert: '1'
    repeatmode: '1'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '1'
    width: '1080'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8080'
  states: {}

connections:
- [blocks_add_xx_0, '0', fosphor_glfw_sink_c_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '0']
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_add_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
