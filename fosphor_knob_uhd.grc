options:
  parameters:
    generate_options: qt_gui
    id: fosphor_knob_uhd
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 56e6
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    label: Current Gain
    type: raw
    value: gain
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'False'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8080'
  states: {}

connections:
- [uhd_usrp_source_0, '0', fosphor_glfw_sink_c_0, '0']

metadata:
  file_format: 1
